Commit message: [urdf/srdf] Update ground + desk model

File: urdf/ground.urdf (robot description, URDF)
Before this commit: robot ground, 1 links, 0 joints
Links:
- removed link world
- added link base_link; collision box size=5 5 0.02; visual box size=5 5 0.02
